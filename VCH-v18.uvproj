# Keil uVision project VCH-v18.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ADuC7026 Analog Devices
  cpu: IRAM(0x10000-0x11FFF) IROM(0x80000-0x8F7FF) CLOCK(32768) CPUTYPE(ARM7TDMI)
  output: VCH-v18
  c flags: Optim=1
  memory RVCT4: ROM 0x80000 size 0xf800
  memory RVCT9: RAM 0x10000 size 0x2000
  group Source
    ./: ADuC702x.s Cepstrum.c Comparefunctions.c Controlmodule.c FFT.c Initializations.c Process.c Processmodule.c Retarget.c Rms.c System.c Variablechannel-v14.c Window.c
  group New Group
    ./: Debug Commands.txt definitions.h VCH-v18.map Sin 1ch.ini Noised Sin 4ch.ini Sin 4ch.ini
